# Repository AlicDanclic/ChinoHub

File Readme.md:

# ChinoHub

由于经常的插拔,导致我的电脑只有一个USB可以用来,是的只有一个了,所以我有必要做一个Hub,之前做一个支持2.0的KVM,但是突然有一个大电流以及没有做外壳导致这个hub由很大的问题,以及,该KVM的设计上仍有很多问题.例如大电流过滤问题,没有静电保护,同时该作为一个DIY项目,他似乎缺少了很多交互性,在参考了[TypeC转HDMI视频输出模块 - 立创开源硬件平台](https://oshwhub.com/lemon_wifi/CS5265)以及[高速USB3.0共享器 四进四出选择 HUB+切换器 - 立创开源硬件平台](https://oshwhub.com/aknice/vl822-ch484m-si-jin-si-chu-usb3-0-hub),我决定开启一个高速PCB的设计项目,ChinoHub,是的,我喜欢看点兔,我最喜欢智乃了❤.

## 项目架构

## 硬件设计注意事项

> 本设计大量用到USB3.0,布线时要遵循高速和差分.

在设计中,我们用到的电源为5V的输入,3.3V和1.0V的输入,(原理图中有1.8V那是芯片自己产生的,在本项目中没用),考虑最坏情况下,对应的峰值电流为:

| 电压域   | 最坏情况峰值电流 | 关键贡献者                                 |
| :------- | :--------------- | :----------------------------------------- |
| **3.3V** | **538 mA**       | VL822(300mA) + CS5265(150mA) + STM32(75mA) |
| **5V**   | **600 mA**       | LP3220输入(400mA) + CS5265(200mA)          |
| **1.0V** | **200 mA**       | VL822(150mA) + CS5265(50mA)                |

所以考虑1.5倍富裕度,这里选择了MP2122A,输出为2A的二路DCDC.同时STM32由LDO单独供电防止纹波问题.计算公式可以参看Datasheet,为:$0.6V \times(1+\frac{R_1}{R_2})$

在设计时候用了一个防浪涌的模拟电路,对于多电源可能同时输入,效果还是不错的.

## 软件烧录

## 使用指南

### 日志

2025.10.4完成原理图绘制,等待审查

## KiCad design Hardware/ChinoHub.kicad_pcb

Parts:
D7, D9: SOD-323F_L1.7-W1.3-LS2.5-R-RD; Manufacturer Part 1N4148WSL; LCSC Part Name 1N4148WSL
R45, R46: 0Ω; R0603; Manufacturer Part 0603WAF1002T5E; LCSC Part Name 厚膜电阻 10kΩ ±1% 100mW
R81, R84, R87, R88: 2.2kΩ; R0603; Manufacturer Part 0603WAF1002T5E; LCSC Part Name 厚膜电阻 10kΩ ±1% 100mW
R90, R91: 10kΩ; R0603; Manufacturer Part 0603WAF1002T5E; LCSC Part Name 厚膜电阻 10kΩ ±1% 100mW

Connections:
+3V3: R90.2, R91.2; also elsewhere on the board
+5V: D7.2, D9.2; also elsewhere on the board
/HDMI_OUT/HDMI_SCL: R46.2, R84.2; also elsewhere on the board
/HDMI_OUT/HDMI_SDA: R45.2, R81.2; also elsewhere on the board
/HDMI_OUT/TMDS_SCL: R87.2; also elsewhere on the board
/HDMI_OUT/TMDS_SDA: R88.2; also elsewhere on the board
/MCU/HDMI_SEL1: R90.1; also elsewhere on the board
/MCU/HDMI_SEL2: R91.1; also elsewhere on the board
/TypeC2HDMI/CFG_SCL: R46.1; also elsewhere on the board
/TypeC2HDMI/CFG_SDA: R45.1; also elsewhere on the board
unnamed: D7.1, R81.1, R84.1
unnamed: D9.1, R87.1, R88.1

Parts:
C25, C26, C27, C28, C29, C30, C31, C32, C33, C34, C35, C36, C37, C38, C39, C40, C41, C42, C43, C44, C45, C46, C47, C48, C49, C50: 100nF; C0603; Manufacturer Part CL10A105KB8NNNC; LCSC Part Name 1uF ±10% 50V
JMP1: JUMP0603
R33, R34, R35: 10kΩ; R0603; Manufacturer Part 0603WAF1002T5E; LCSC Part Name 厚膜电阻 10kΩ ±1% 100mW
R36, R37, R38, R39, R44: NC; R0603; Manufacturer Part 0603WAF1002T5E; LCSC Part Name 厚膜电阻 10kΩ ±1% 100mW
R40, R41: 1M; R0603; Manufacturer Part 0603WAF1002T5E; LCSC Part Name 厚膜电阻 10kΩ ±1% 100mW
R42: 47k; R0603; Manufacturer Part 0603WAF1002T5E; LCSC Part Name 厚膜电阻 10kΩ ±1% 100mW
R43: 330k; R0603; Manufacturer Part 0603WAF1002T5E; LCSC Part Name 厚膜电阻 10kΩ ±1% 100mW
U5: MQFN-28_L4.5-W3.5-P0.40-BL-EP
U6: QFN-68

Connections:
+1V0: C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, U6.5 (RX_AVDD10), U6.17 (RX_AVDD10), U6.21 (VDD10), U6.42 (VDD10), U6.43 (AVDD10_TX), U6.52 (AVDD10_TX), U6.53 (AVDD10_PLL), U6.62 (VDD10); also elsewhere on the board
+1V8: C49.2, C50.2, U6.11 (RX_AVDD18)
+3V3: C25.2, JMP1.2, R33.1, R34.1, R38.1, R39.1, U5.22 (VCC); also elsewhere on the board
+5V: R43.2, U6.32 (VDD5_IN), U6.33 (VDD5_IN); also elsewhere on the board
/HDMI_OUT/HDMI_CK_N: U6.44 (HDMI_CKN); also elsewhere on the board
/HDMI_OUT/HDMI_CK_P: U6.45 (HDMI_CKP); also elsewhere on the board
/HDMI_OUT/HDMI_D0_N: U6.46 (HDMI_D0N); also elsewhere on the board
/HDMI_OUT/HDMI_D0_P: U6.47 (HDMI_D0P); also elsewhere on the board
/HDMI_OUT/HDMI_D1_N: U6.48 (HDMI_D1P); also elsewhere on the board
/HDMI_OUT/HDMI_D1_P: U6.49 (HDMI_D1P); also elsewhere on the board
/HDMI_OUT/HDMI_D2_N: U6.50 (HDMI_D2N); also elsewhere on the board
/HDMI_OUT/HDMI_D2_P: U6.51 (HDMI_D2P); also elsewhere on the board
/HDMI_OUT/HDMI_HPD: U6.38 (HDMI_HPD); also elsewhere on the board
/HDMI_OUT/HDMI_SCL: U6.40 (HDMI_SCL); also elsewhere on the board
/HDMI_OUT/HDMI_SDA: U6.39 (HDMI_SDA); also elsewhere on the board
/MCU/GPIO_1: U6.58 (GPIO1); also elsewhere on the board
/MCU/GPIO_2: U6.59 (GPIO2); also elsewhere on the board
/TypeC2HDMI/3V3_OUT: JMP1.1, U6.30 (VDD33_OUT), U6.31 (VDD33_OUT)
/TypeC2HDMI/5265_3V3: C44.2, C45.2, C46.2, C47.2, C48.2, JMP1.3, R44.1, U6.4 (RX_AVDD33), U6.18 (RX_AVDD33), U6.37 (AVDD33), U6.54 (AVDD33_PLL), U6.55 (AVDD33_IO)
/TypeC2HDMI/AUX_N: C35.2, R39.2, R41.2, U5.13 (SBU1)
/TypeC2HDMI/AUX_P: C34.2, R38.2, R40.2, U5.14 (SBU2)
/TypeC2HDMI/CFG_SCL: U6.56 (CFG_SCL); also elsewhere on the board
/TypeC2HDMI/CFG_SDA: U6.57 (CFG_SDA); also elsewhere on the board
/TypeC2HDMI/EN: R33.2, U5.17 (EN)
/TypeC2HDMI/HDMI_CC1: U6.1 (UFP_CC1); also elsewhere on the board
/TypeC2HDMI/HDMI_CC2: U6.68 (UFP_CC2); also elsewhere on the board
/TypeC2HDMI/HDMI_CSBU1: R36.1, U5.11 (CSBU1); also elsewhere on the board
/TypeC2HDMI/HDMI_CSBU2: R37.1, U5.12 (CSBU2); also elsewhere on the board
/TypeC2HDMI/HDMI_RX1_N: U5.2 (RX1_N); also elsewhere on the board
/TypeC2HDMI/HDMI_RX1_P: U5.1 (RX1_P); also elsewhere on the board
/TypeC2HDMI/HDMI_RX2_N: U5.10 (RX2_N); also elsewhere on the board
/TypeC2HDMI/HDMI_RX2_P: U5.9 (RX2_P); also elsewhere on the board
/TypeC2HDMI/HDMI_TX1_N: U5.5 (TX1_N); also elsewhere on the board
/TypeC2HDMI/HDMI_TX1_P: U5.4 (TX1_P); also elsewhere on the board
/TypeC2HDMI/HDMI_TX2_N: U5.7 (TX2_N); also elsewhere on the board
/TypeC2HDMI/HDMI_TX2_P: U5.6 (TX2_P); also elsewhere on the board
/TypeC2HDMI/HDMI_USB_D_N: U6.20 (BB_DM); also elsewhere on the board
/TypeC2HDMI/HDMI_USB_D_P: U6.19 (BB_DP); also elsewhere on the board
/TypeC2HDMI/IN0_N: C27.2, U5.23 (LND_N)
/TypeC2HDMI/IN0_P: C26.2, U5.24 (LND_P)
/TypeC2HDMI/IN1_N: C29.2, U5.20 (LNC_N)
/TypeC2HDMI/IN1_P: C28.2, U5.21 (LNC_P)
/TypeC2HDMI/IN2_N: C31.2, U5.18 (LNB_N)
/TypeC2HDMI/IN2_P: C30.2, U5.19 (LNB_P)
/TypeC2HDMI/IN3_N: C33.2, U5.15 (LNA_N)
/TypeC2HDMI/IN3_P: C32.2, U5.16 (LNA_P)
/TypeC2HDMI/POL: R35.2, U5.3 (POL), U6.23 (GPIO5)
/TypeC2HDMI/SEL: R34.2, U5.8 (AMSEL)
GND: C25.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, C47.1, C48.1, C49.1, C50.1, R35.1, R36.2, R37.2, R40.1, R41.1, R42.1, U5.29 (GND), U6.8 (GND), U6.14 (GND), U6.22 (TEST_EN), U6.63 (GND), U6.64 (NC), U6.65 (NC), U6.66 (NC), U6.69 (EP); also elsewhere on the board
unnamed: C35.1, U6.2 (AUX_N)
unnamed: C34.1, U6.3 (AUX_P)
unnamed: C27.1, U6.7 (LANE0_N)
unnamed: C26.1, U6.6 (LANE0_P)
unnamed: C29.1, U6.10 (LANE1_N)
unnamed: C28.1, U6.9 (LANE1_P)
unnamed: C31.1, U6.13 (LANE2_N)
unnamed: C30.1, U6.12 (LANE2_P)
unnamed: C33.1, U6.16 (LANE3_N)
unnamed: C32.1, U6.15 (LANE3_P)
unnamed: R42.2, R43.1, U6.67 (VBUS_MON_U)
unnamed: R44.2, U6.25 (GPIO7)

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C20, C22, C24: 100nF; C0603; Manufacturer Part CL10A105KB8NNNC; LCSC Part Name 1uF ±10% 50V
C18, C19, C21, C23: 10uF; C0603; Manufacturer Part CL10A105KB8NNNC; LCSC Part Name 1uF ±10% 50V
R1, R25, R28, R31: 20kΩ; R0603; Manufacturer Part 0603WAF1002T5E; LCSC Part Name 厚膜电阻 10kΩ ±1% 100mW
R2, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R26, R29, R32: 10kΩ; R0603; Manufacturer Part 0603WAF1002T5E; LCSC Part Name 厚膜电阻 10kΩ ±1% 100mW
R3, R24, R27, R30: 510; R0603; Manufacturer Part 0603WAF1002T5E; LCSC Part Name 厚膜电阻 10kΩ ±1% 100mW
U1, U2, U3, U4: MQFN-28_L4.5-W3.5-P0.40-BL-EP; Manufacturer Part VL160; LCSC Part Name VL160
USB1, USB2, USB3, USB4, USB5: TYPE-C-SMD_TYPE-C-24P-QCHT; Manufacturer Part TYPE-C 24P QCHT; LCSC Part Name Type-C 母 卧贴
USB6: HDMI-SMD_HDMI-001S; Manufacturer Part HDMI-001S; LCSC Part Name HDMI-001S

Connections:
/HDMI_OUT/TMDS_CLK_N: USB6.12 (TMDS_Clock-); also elsewhere on the board
/HDMI_OUT/TMDS_CLK_P: USB6.10 (TMDS_Clock+); also elsewhere on the board
/HDMI_OUT/TMDS_D0_N: USB6.9 (TMDS_Data_0-); also elsewhere on the board
/HDMI_OUT/TMDS_D0_P: USB6.7 (TMDS_Data_0+); also elsewhere on the board
/HDMI_OUT/TMDS_D1_N: USB6.6 (TMDS_Data_1-); also elsewhere on the board
/HDMI_OUT/TMDS_D1_P: USB6.4 (TMDS_Data_1+); also elsewhere on the board
/HDMI_OUT/TMDS_D2_N: USB6.3 (TMDS_Data_2-); also elsewhere on the board
/HDMI_OUT/TMDS_D2_P: USB6.1 (TMDS_Data_2+); also elsewhere on the board
/HDMI_OUT/TMDS_HPD: USB6.19 (Hot_Plug_Detect); also elsewhere on the board
/HDMI_OUT/TMDS_SCL: USB6.15 (SCL); also elsewhere on the board
/HDMI_OUT/TMDS_SDA: USB6.16 (SDA); also elsewhere on the board
/Power/HDMI_VBUS: USB1.A4 (VBUS), USB1.A9 (VBUS), USB1.B4 (VBUS), USB1.B9 (VBUS); also elsewhere on the board
/Power/TMDS_5V: USB6.18 (+5V_Power); also elsewhere on the board
/Power/TypeC_1_5V: C17.2, C18.2, R4.2, R5.2, R6.2, USB2.A4 (VBUS), USB2.A9 (VBUS), USB2.B4 (VBUS), USB2.B9 (VBUS); also elsewhere on the board
/Power/TypeC_2_5V: C19.2, C20.2, R9.2, R10.2, R12.2, USB3.A4 (VBUS), USB3.A9 (VBUS), USB3.B4 (VBUS), USB3.B9 (VBUS); also elsewhere on the board
/Power/TypeC_3_5V: C21.2, C22.2, R14.2, R15.2, R17.2, USB4.A4 (VBUS), USB4.A9 (VBUS), USB4.B4 (VBUS), USB4.B9 (VBUS); also elsewhere on the board
/Power/TypeC_4_5V: C23.2, C24.2, R19.2, R20.2, R22.2, USB5.A4 (VBUS), USB5.A9 (VBUS), USB5.B4 (VBUS), USB5.B9 (VBUS); also elsewhere on the board
/TypeC2HDMI/HDMI_CC1: USB1.A5 (CC1); also elsewhere on the board
/TypeC2HDMI/HDMI_CC2: USB1.B5 (CC2); also elsewhere on the board
/TypeC2HDMI/HDMI_CSBU1: USB1.A8 (SBU1); also elsewhere on the board
/TypeC2HDMI/HDMI_CSBU2: USB1.B8 (SBU2); also elsewhere on the board
/TypeC2HDMI/HDMI_RX1_N: USB1.B10 (RX1-); also elsewhere on the board
/TypeC2HDMI/HDMI_RX1_P: USB1.B11 (RX1+); also elsewhere on the board
/TypeC2HDMI/HDMI_RX2_N: USB1.A10 (RX2-); also elsewhere on the board
/TypeC2HDMI/HDMI_RX2_P: USB1.A11 (RX2+); also elsewhere on the board
/TypeC2HDMI/HDMI_TX1_N: USB1.A3 (TX1-); also elsewhere on the board
/TypeC2HDMI/HDMI_TX1_P: USB1.A2 (TX1+); also elsewhere on the board
/TypeC2HDMI/HDMI_TX2_N: USB1.B3 (TX2-); also elsewhere on the board
/TypeC2HDMI/HDMI_TX2_P: USB1.B2 (TX2+); also elsewhere on the board
/TypeC2HDMI/HDMI_USB_D_N: USB1.A7 (D-), USB1.B7 (D-); also elsewhere on the board
/TypeC2HDMI/HDMI_USB_D_P: USB1.A6 (D+), USB1.B6 (D+); also elsewhere on the board
/TypeC3.0Handle/TypeC_1_CC1: U1.1 (CC1), USB2.A5 (CC1)
/TypeC3.0Handle/TypeC_1_CC2: U1.28 (CC2), USB2.B5 (CC2)
/TypeC3.0Handle/TypeC_1_D_N: USB2.A7 (D-), USB2.B7 (D-); also elsewhere on the board
/TypeC3.0Handle/TypeC_1_D_P: USB2.A6 (D+), USB2.B6 (D+); also elsewhere on the board
/TypeC3.0Handle/TypeC_1_RX1_N: U1.7 (RX1_N), USB2.B10 (RX1-)
/TypeC3.0Handle/TypeC_1_RX1_P: U1.6 (RX1_P), USB2.B11 (RX1+)
/TypeC3.0Handle/TypeC_1_RX2_N: U1.8 (RX2_N), USB2.A10 (RX2-)
/TypeC3.0Handle/TypeC_1_RX2_P: U1.9 (RX2_P), USB2.A11 (RX2+)
/TypeC3.0Handle/TypeC_1_TX1_N: C14.1, U1.3 (TX1_N)
/TypeC3.0Handle/TypeC_1_TX1_P: C13.1, U1.2 (TX1_P)
/TypeC3.0Handle/TypeC_1_TX2_N: C15.2, U1.4 (TX2_N)
/TypeC3.0Handle/TypeC_1_TX2_P: C16.2, U1.5 (TX2_P)
/TypeC3.0Handle/TypeC_2_CC1: U2.1 (CC1), USB3.A5 (CC1)
/TypeC3.0Handle/TypeC_2_CC2: U2.28 (CC2), USB3.B5 (CC2)
/TypeC3.0Handle/TypeC_2_D_N: USB3.A7 (D-), USB3.B7 (D-); also elsewhere on the board
/TypeC3.0Handle/TypeC_2_D_P: USB3.A6 (D+), USB3.B6 (D+); also elsewhere on the board
/TypeC3.0Handle/TypeC_2_RX1_N: U2.7 (RX1_N), USB3.B10 (RX1-)
/TypeC3.0Handle/TypeC_2_RX1_P: U2.6 (RX1_P), USB3.B11 (RX1+)
/TypeC3.0Handle/TypeC_2_RX2_N: U2.8 (RX2_N), USB3.A10 (RX2-)
/TypeC3.0Handle/TypeC_2_RX2_P: U2.9 (RX2_P), USB3.A11 (RX2+)
/TypeC3.0Handle/TypeC_2_TX1_N: C10.1, U2.3 (TX1_N)
/TypeC3.0Handle/TypeC_2_TX1_P: C9.1, U2.2 (TX1_P)
/TypeC3.0Handle/TypeC_2_TX2_N: C11.2, U2.4 (TX2_N)
/TypeC3.0Handle/TypeC_2_TX2_P: C12.2, U2.5 (TX2_P)
/TypeC3.0Handle/TypeC_3_CC1: U4.1 (CC1), USB4.A5 (CC1)
/TypeC3.0Handle/TypeC_3_CC2: U4.28 (CC2), USB4.B5 (CC2)
/TypeC3.0Handle/TypeC_3_D_N: USB4.A7 (D-), USB4.B7 (D-); also elsewhere on the board
/TypeC3.0Handle/TypeC_3_D_P: USB4.A6 (D+), USB4.B6 (D+); also elsewhere on the board
/TypeC3.0Handle/TypeC_3_RX1_N: U4.7 (RX1_N), USB4.B10 (RX1-)
/TypeC3.0Handle/TypeC_3_RX1_P: U4.6 (RX1_P), USB4.B11 (RX1+)
/TypeC3.0Handle/TypeC_3_RX2_N: U4.8 (RX2_N), USB4.A10 (RX2-)
/TypeC3.0Handle/TypeC_3_RX2_P: U4.9 (RX2_P), USB4.A11 (RX2+)
/TypeC3.0Handle/TypeC_3_TX1_N: C6.1, U4.3 (TX1_N)
/TypeC3.0Handle/TypeC_3_TX1_P: C5.1, U4.2 (TX1_P)
/TypeC3.0Handle/TypeC_3_TX2_N: C7.2, U4.4 (TX2_N)
/TypeC3.0Handle/TypeC_3_TX2_P: C8.2, U4.5 (TX2_P)
/TypeC3.0Handle/TypeC_4_CC1: U3.1 (CC1), USB5.A5 (CC1)
/TypeC3.0Handle/TypeC_4_CC2: U3.28 (CC2), USB5.B5 (CC2)
/TypeC3.0Handle/TypeC_4_D_N: USB5.A7 (D-), USB5.B7 (D-); also elsewhere on the board
/TypeC3.0Handle/TypeC_4_D_P: USB5.A6 (D+), USB5.B6 (D+); also elsewhere on the board
/TypeC3.0Handle/TypeC_4_RX1_N: U3.7 (RX1_N), USB5.B10 (RX1-)
/TypeC3.0Handle/TypeC_4_RX1_P: U3.6 (RX1_P), USB5.B11 (RX1+)
/TypeC3.0Handle/TypeC_4_RX2_N: U3.8 (RX2_N), USB5.A10 (RX2-)
/TypeC3.0Handle/TypeC_4_RX2_P: U3.9 (RX2_P), USB5.A11 (RX2+)
/TypeC3.0Handle/TypeC_4_TX1_N: C2.1, U3.3 (TX1_N)
/TypeC3.0Handle/TypeC_4_TX1_P: C1.1, U3.2 (TX1_P)
/TypeC3.0Handle/TypeC_4_TX2_N: C3.2, U3.4 (TX2_N)
/TypeC3.0Handle/TypeC_4_TX2_P: C4.2, U3.5 (TX2_P)
/TypeC3.0Handle/USB_IN_1_RX_N: U1.17 (RX_N); also elsewhere on the board
/TypeC3.0Handle/USB_IN_1_RX_P: U1.18 (RX_P); also elsewhere on the board
/TypeC3.0Handle/USB_IN_1_TX_N: U1.20 (TXN); also elsewhere on the board
/TypeC3.0Handle/USB_IN_1_TX_P: U1.21 (TXP); also elsewhere on the board
/TypeC3.0Handle/USB_IN_2_RX_N: U2.17 (RX_N); also elsewhere on the board
/TypeC3.0Handle/USB_IN_2_RX_P: U2.18 (RX_P); also elsewhere on the board
/TypeC3.0Handle/USB_IN_2_TX_N: U2.20 (TXN); also elsewhere on the board
/TypeC3.0Handle/USB_IN_2_TX_P: U2.21 (TXP); also elsewhere on the board
/TypeC3.0Handle/USB_IN_3_RX_N: U4.17 (RX_N); also elsewhere on the board
/TypeC3.0Handle/USB_IN_3_RX_P: U4.18 (RX_P); also elsewhere on the board
/TypeC3.0Handle/USB_IN_3_TX_N: U4.20 (TXN); also elsewhere on the board
/TypeC3.0Handle/USB_IN_3_TX_P: U4.21 (TXP); also elsewhere on the board
/TypeC3.0Handle/USB_IN_4_RX_N: U3.17 (RX_N); also elsewhere on the board
/TypeC3.0Handle/USB_IN_4_RX_P: U3.18 (RX_P); also elsewhere on the board
/TypeC3.0Handle/USB_IN_4_TX_N: U3.20 (TXN); also elsewhere on the board
/TypeC3.0Handle/USB_IN_4_TX_P: U3.21 (TXP); also elsewhere on the board
GND: C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, R2.1, R3.1, R7.1, R8.1, R11.1, R13.1, R16.1, R18.1, R21.1, R23.1, R24.1, R26.1, R27.1, R29.1, R30.1, R32.1, U1.19 (GND), U1.29 (EP), U2.19 (GND), U2.29 (EP), U3.19 (GND), U3.29 (EP), U4.19 (GND), U4.29 (EP), USB1.25 (EH), USB1.A1 (GND), USB1.A12 (GND), USB1.B1 (GND), USB1.B12 (GND), USB2.25 (EH), USB2.A1 (GND), USB2.A12 (GND), USB2.B1 (GND), USB2.B12 (GND), USB3.25 (EH), USB3.A1 (GND), USB3.A12 (GND), USB3.B1 (GND), USB3.B12 (GND), USB4.25 (EH), USB4.A1 (GND), USB4.A12 (GND), USB4.B1 (GND), USB4.B12 (GND), USB5.25 (EH), USB5.A1 (GND), USB5.A12 (GND), USB5.B1 (GND), USB5.B12 (GND), USB6.2 (TMDS_Data_2_Shield), USB6.5 (TMDS_Data_1_Shield), USB6.8 (TMDS_Data_0_Shield), USB6.11 (TMDS_Clock_Shield), USB6.17 (DDC/CEC_Ground), USB6.20 (GND), USB6.21 (GND), USB6.22 (GND), USB6.23 (GND); also elsewhere on the board
unnamed: R1.1, R3.2
unnamed: R5.1, R7.2, U1.24 (CurrentSettingin)
unnamed: R6.1, R8.2, U1.23 (CurrentSettingin)
unnamed: R10.1, R11.2, U2.24 (CurrentSettingin)
unnamed: R12.1, R13.2, U2.23 (CurrentSettingin)
unnamed: R15.1, R16.2, U4.24 (CurrentSettingin)
unnamed: R17.1, R18.2, U4.23 (CurrentSettingin)
unnamed: R20.1, R21.2, U3.24 (CurrentSettingin)
unnamed: R22.1, R23.2, U3.23 (CurrentSettingin)
unnamed: R24.2, R25.1
unnamed: R27.2, R28.1
unnamed: R30.2, R31.1
unnamed: R4.1, U1.25 (CE)
unnamed: R2.2, U1.13 (High_Z)
unnamed: R1.2, U1.10 (REXT)
unnamed: U1.26 (VCC5V), U1.27 (Vconn_5Vin)
unnamed: R9.1, U2.25 (CE)
unnamed: R26.2, U2.13 (High_Z)
unnamed: R25.2, U2.10 (REXT)
unnamed: U2.26 (VCC5V), U2.27 (Vconn_5Vin)
unnamed: R19.1, U3.25 (CE)
unnamed: R32.2, U3.13 (High_Z)
unnamed: R31.2, U3.10 (REXT)
unnamed: U3.26 (VCC5V), U3.27 (Vconn_5Vin)
unnamed: R14.1, U4.25 (CE)
unnamed: R29.2, U4.13 (High_Z)
unnamed: R28.2, U4.10 (REXT)
unnamed: U4.26 (VCC5V), U4.27 (Vconn_5Vin)
unnamed: C13.2, USB2.A2 (TX1+)
unnamed: C14.2, USB2.A3 (TX1-)
unnamed: C16.1, USB2.B2 (TX2+)
unnamed: C15.1, USB2.B3 (TX2-)
unnamed: C9.2, USB3.A2 (TX1+)
unnamed: C10.2, USB3.A3 (TX1-)
unnamed: C12.1, USB3.B2 (TX2+)
unnamed: C11.1, USB3.B3 (TX2-)
unnamed: C5.2, USB4.A2 (TX1+)
unnamed: C6.2, USB4.A3 (TX1-)
unnamed: C8.1, USB4.B2 (TX2+)
unnamed: C7.1, USB4.B3 (TX2-)
unnamed: C1.2, USB5.A2 (TX1+)
unnamed: C2.2, USB5.A3 (TX1-)
unnamed: C4.1, USB5.B2 (TX2+)
unnamed: C3.1, USB5.B3 (TX2-)

Notes on the sheet:
HUB的上游TypeC
TypeC转HDMI不进行预处理后续处理较为麻烦
HDMI输入
TypeC转USB3.0
TypeC转HDMI输入
