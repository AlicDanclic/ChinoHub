# Repository AlicDanclic/ChinoHub (continued)

## KiCad design Hardware/ChinoHub.kicad_pcb (continued)

Parts:
C51, C52, C53, C54, C55, C56, C57, C58, C59, C60, C61, C62, C63, C64, C65, C66, C67, C68, C69, C70, C71, C72, C73, C74, C75, C76, C77, C78: 100nF; C0603; Manufacturer Part CL10A105KB8NNNC; LCSC Part Name 1uF ±10% 50V
C79: 1uF; C0603; Manufacturer Part CL10A105KB8NNNC; LCSC Part Name 1uF ±10% 50V
C80, C81: 20pF; C0603; Manufacturer Part CL10A105KB8NNNC; LCSC Part Name 1uF ±10% 50V
LED1, LED2, LED3, LED4: LED0603-RD; Manufacturer Part LTST-C190KSKT; LCSC Part Name 黄灯
R47: 12.4K; R0603; Manufacturer Part 0603WAF1002T5E; LCSC Part Name 厚膜电阻 10kΩ ±1% 100mW
R48, R51, R52, R53, R54, R55, R56, R61, R62, R63: 4.7K; R0603; Manufacturer Part 0603WAF1002T5E; LCSC Part Name 厚膜电阻 10kΩ ±1% 100mW
R49: 10K; R0603; Manufacturer Part 0603WAF1002T5E; LCSC Part Name 厚膜电阻 10kΩ ±1% 100mW
R50: 2M; R0603; Manufacturer Part 0603WAF1002T5E; LCSC Part Name 厚膜电阻 10kΩ ±1% 100mW
R57, R58, R59, R60: 100; R0603; Manufacturer Part 0603WAF1002T5E; LCSC Part Name 厚膜电阻 10kΩ ±1% 100mW
U7, U8: QFN-42_L9.0-W3.5-P0.50-EP7.6; Manufacturer Part CH484M; LCSC Part Name 差分通道四选一、四刀四掷超高速模拟开关芯片CH484M
U9: QFN-76_L9.0-W9.0-P0.40-EP6.3-TL; Manufacturer Part VL822-QFN76; LCSC Part Name VL822 USB 3.1 Gen2 Hub Controller
X1: 25MHz; CRYSTAL-SMD_4P-L3.2-W2.5-BL; Manufacturer Part TAXM11.0592M4RLBCCT2T; LCSC Part Name 11.0592MHz ±10ppm 20pF

Connections:
+1V0: C70.1, C71.1, C72.1, C73.1, C74.1, C75.1, C76.1, C77.1, C78.1, U9.5 (VCC10I), U9.8 (VCC10I), U9.11 (VDD), U9.14 (VCC10I), U9.27 (VCC10I), U9.30 (VDD), U9.33 (VCC10I), U9.36 (VCC10I), U9.48 (VDD), U9.51 (VCC10I), U9.54 (VCC10I), U9.67 (VDD); also elsewhere on the board
+3V3: C51.1, C52.1, C53.1, C54.1, C65.1, C66.1, C67.1, C68.1, C69.1, R51.1, R52.1, R53.1, R54.2, R55.1, R61.1, R62.1, R63.1, U7.5 (VDD), U7.14 (VDD), U8.5 (VDD), U8.14 (VDD), U9.17 (VCC33I), U9.24 (VCC33I), U9.46 (VCC33I), U9.62 (VCC33I), U9.73 (VCC33I); also elsewhere on the board
+5V: R48.1; also elsewhere on the board
/MCU/HUB_SEL0: U7.4 (SEL0), U7.13 (SEL0), U8.4 (SEL0), U8.13 (SEL0); also elsewhere on the board
/MCU/HUB_SEL1: U7.3 (SEL1), U8.3 (SEL1); also elsewhere on the board
/OUT_HUB/HSD_1_N: U9.10 (HSD1–); also elsewhere on the board
/OUT_HUB/HSD_1_P: U9.9 (HSD1+); also elsewhere on the board
/OUT_HUB/HSD_2_N: U9.19 (HSD2–); also elsewhere on the board
/OUT_HUB/HSD_2_P: U9.18 (HSD2+); also elsewhere on the board
/OUT_HUB/HSD_3_N: U9.23 (HSD3–); also elsewhere on the board
/OUT_HUB/HSD_3_P: U9.22 (HSD3+); also elsewhere on the board
/OUT_HUB/HSD_4_N: U9.38 (HSD4–); also elsewhere on the board
/OUT_HUB/HSD_4_P: U9.37 (HSD4+); also elsewhere on the board
/OUT_HUB/SSRX1_N: U9.7 (SSRX1–); also elsewhere on the board
/OUT_HUB/SSRX1_P: U9.6 (SSRX1+); also elsewhere on the board
/OUT_HUB/SSRX2_N: U9.16 (SSRX2–); also elsewhere on the board
/OUT_HUB/SSRX2_P: U9.15 (SSRX2+); also elsewhere on the board
/OUT_HUB/SSRX3_N: U9.29 (SSRX3–); also elsewhere on the board
/OUT_HUB/SSRX3_P: U9.28 (SSRX3+); also elsewhere on the board
/OUT_HUB/SSRX4_N: U9.35 (SSRX4–); also elsewhere on the board
/OUT_HUB/SSRX4_P: U9.34 (SSRX4+); also elsewhere on the board
/OUT_HUB/SSTX1_N: C58.2; also elsewhere on the board
/OUT_HUB/SSTX1_P: C57.2; also elsewhere on the board
/OUT_HUB/SSTX2_N: C60.2; also elsewhere on the board
/OUT_HUB/SSTX2_P: C59.2; also elsewhere on the board
/OUT_HUB/SSTX3_N: C62.2; also elsewhere on the board
/OUT_HUB/SSTX3_P: C61.2; also elsewhere on the board
/OUT_HUB/SSTX4_N: C64.2; also elsewhere on the board
/OUT_HUB/SSTX4_P: C63.2; also elsewhere on the board
/TypeC3.0Handle/TypeC_1_D_N: U7.37 (SSA0Y); also elsewhere on the board
/TypeC3.0Handle/TypeC_1_D_P: U7.38 (SSA0X); also elsewhere on the board
/TypeC3.0Handle/TypeC_2_D_N: U7.33 (SSA1Y); also elsewhere on the board
/TypeC3.0Handle/TypeC_2_D_P: U7.34 (SSA1X); also elsewhere on the board
/TypeC3.0Handle/TypeC_3_D_N: U7.28 (SSA2Y); also elsewhere on the board
/TypeC3.0Handle/TypeC_3_D_P: U7.29 (SSA2X); also elsewhere on the board
/TypeC3.0Handle/TypeC_4_D_N: U7.24 (SSA3Y); also elsewhere on the board
/TypeC3.0Handle/TypeC_4_D_P: U7.25 (SSA3X); also elsewhere on the board
/TypeC3.0Handle/USB_IN_1_RX_N: U8.37 (SSA0Y); also elsewhere on the board
/TypeC3.0Handle/USB_IN_1_RX_P: U8.38 (SSA0X); also elsewhere on the board
/TypeC3.0Handle/USB_IN_1_TX_N: U8.35 (SSB0Y); also elsewhere on the board
/TypeC3.0Handle/USB_IN_1_TX_P: U8.36 (SSB0X); also elsewhere on the board
/TypeC3.0Handle/USB_IN_2_RX_N: U8.33 (SSA1Y); also elsewhere on the board
/TypeC3.0Handle/USB_IN_2_RX_P: U8.34 (SSA1X); also elsewhere on the board
/TypeC3.0Handle/USB_IN_2_TX_N: U8.31 (SSB1Y); also elsewhere on the board
/TypeC3.0Handle/USB_IN_2_TX_P: U8.32 (SSB1X); also elsewhere on the board
/TypeC3.0Handle/USB_IN_3_RX_N: U8.28 (SSA2Y); also elsewhere on the board
/TypeC3.0Handle/USB_IN_3_RX_P: U8.29 (SSA2X); also elsewhere on the board
/TypeC3.0Handle/USB_IN_3_TX_N: U8.26 (SSB2Y); also elsewhere on the board
/TypeC3.0Handle/USB_IN_3_TX_P: U8.27 (SSB2X); also elsewhere on the board
/TypeC3.0Handle/USB_IN_4_RX_N: U8.24 (SSA3Y); also elsewhere on the board
/TypeC3.0Handle/USB_IN_4_RX_P: U8.25 (SSA3X); also elsewhere on the board
/TypeC3.0Handle/USB_IN_4_TX_N: U8.22 (SSB3Y); also elsewhere on the board
/TypeC3.0Handle/USB_IN_4_TX_P: U8.23 (SSB3X); also elsewhere on the board
/USB_HUB/HUB_D_N: U7.8 (SSAY), U9.56 (HSD0–)
/USB_HUB/HUB_D_P: U7.7 (SSAX), U9.55 (HSD0+)
/USB_HUB/HUB_RX_N: U8.8 (SSAY), U9.52 (SSRX0–)
/USB_HUB/HUB_RX_P: U8.7 (SSAX), U9.53 (SSRX0+)
/USB_HUB/HUB_TX_N: C55.1, U8.11 (SSBY)
/USB_HUB/HUB_TX_P: C56.1, U8.10 (SSBX)
/USB_HUB/HUB_XI: C80.1, U9.45 (USB3XI), X1.1 (OSC1)
/USB_HUB/HUB_XO: C81.2, U9.44 (USB3XO), X1.3 (OSC2)
GND: C51.2, C52.2, C53.2, C54.2, C65.2, C66.2, C67.2, C68.2, C69.2, C70.2, C71.2, C72.2, C73.2, C74.2, C75.2, C76.2, C77.2, C78.2, C79.1, C80.2, C81.1, LED1.1 (-), LED2.1 (-), LED3.1 (-), LED4.1 (-), R47.1, R49.1, R56.1, U7.6 (GND), U7.9 (GND), U7.12 (GND), U7.15 (GND), U7.21 (GND), U7.30 (GND), U7.39 (GND), U7.43 (GND), U8.6 (GND), U8.9 (GND), U8.12 (GND), U8.15 (GND), U8.21 (GND), U8.30 (GND), U8.39 (GND), U8.43 (GND), U9.77 (EP), X1.2 (GND), X1.4 (GND); also elsewhere on the board
unnamed: LED1.2 (+), R60.1
unnamed: LED2.2 (+), R58.1
unnamed: LED3.2 (+), R57.1
unnamed: LED4.2 (+), R59.1
unnamed: R48.2, R49.2, R50.1
unnamed: R62.2, U9.65 (GPIO7/SMDAT)
unnamed: R61.2, U9.66 (GPIO8/SMCLK)
unnamed: C79.2, R63.2, U9.68 (RESET#)
unnamed: R47.2, U9.47 (REXT)
unnamed: C56.2, U9.50 (SSTX0+)
unnamed: C55.2, U9.49 (SSTX0–)
unnamed: C57.1, U9.3 (SSTX1+)
unnamed: C58.1, U9.4 (SSTX1–)
unnamed: C59.1, U9.12 (SSTX2+)
unnamed: C60.1, U9.13 (SSTX2–)
unnamed: C61.1, U9.25 (SSTX3+)
unnamed: C62.1, U9.26 (SSTX3–)
unnamed: C63.1, U9.31 (SSTX4+)
unnamed: C64.1, U9.32 (SSTX4–)
unnamed: R56.2, U9.74 (TESTEN)
unnamed: R59.2, U9.69 (USBLED1/SPISI)
unnamed: R57.2, U9.70 (USBLED2/SPICK)
unnamed: R58.2, U9.71 (USBLED3/SPISO)
unnamed: R60.2, U9.72 (USBLED4/SPICS)
unnamed: R51.2, U9.41 (USBOC0)
unnamed: R53.2, U9.1 (USBOC1)
unnamed: R55.2, U9.75 (USBOC2)
unnamed: R54.1, U9.20 (USBOC3)
unnamed: R52.2, U9.40 (USBOC4)
unnamed: R50.2, U9.43 (VBUSDET0)

Parts:
C82, C84, C86, C88: 100nF; C0603; Manufacturer Part CL10A105KB8NNNC; LCSC Part Name 1uF ±10% 50V
C83, C85, C87, C89: 100uF; C0603; Manufacturer Part CL10A105KB8NNNC; LCSC Part Name 1uF ±10% 50V
U10, U11, U12, U13: USB-TH_USB3.0-A; Manufacturer Part HC-USB3.0-L168-WP; LCSC Part Name Type-A 母 弯插 USB3.0 A母90度 弯脚蓝色平口 吸塑盒

Connections:
+5V: C82.1, C83.1, C84.1, C85.1, C86.1, C87.1, C88.1, C89.1, U10.1 (VBUS), U11.1 (VBUS), U12.1 (VBUS), U13.1 (VBUS); also elsewhere on the board
/OUT_HUB/HSD_1_N: U10.2 (D-); also elsewhere on the board
/OUT_HUB/HSD_1_P: U10.3 (D+); also elsewhere on the board
/OUT_HUB/HSD_2_N: U11.2 (D-); also elsewhere on the board
/OUT_HUB/HSD_2_P: U11.3 (D+); also elsewhere on the board
/OUT_HUB/HSD_3_N: U12.2 (D-); also elsewhere on the board
/OUT_HUB/HSD_3_P: U12.3 (D+); also elsewhere on the board
/OUT_HUB/HSD_4_N: U13.2 (D-); also elsewhere on the board
/OUT_HUB/HSD_4_P: U13.3 (D+); also elsewhere on the board
/OUT_HUB/SSRX1_N: U10.5 (SSRX-); also elsewhere on the board
/OUT_HUB/SSRX1_P: U10.6 (SSRX+); also elsewhere on the board
/OUT_HUB/SSRX2_N: U11.5 (SSRX-); also elsewhere on the board
/OUT_HUB/SSRX2_P: U11.6 (SSRX+); also elsewhere on the board
/OUT_HUB/SSRX3_N: U12.5 (SSRX-); also elsewhere on the board
/OUT_HUB/SSRX3_P: U12.6 (SSRX+); also elsewhere on the board
/OUT_HUB/SSRX4_N: U13.5 (SSRX-); also elsewhere on the board
/OUT_HUB/SSRX4_P: U13.6 (SSRX+); also elsewhere on the board
/OUT_HUB/SSTX1_N: U10.8 (SSTX-); also elsewhere on the board
/OUT_HUB/SSTX1_P: U10.9 (SSTX+); also elsewhere on the board
/OUT_HUB/SSTX2_N: U11.8 (SSTX-); also elsewhere on the board
/OUT_HUB/SSTX2_P: U11.9 (SSTX+); also elsewhere on the board
/OUT_HUB/SSTX3_N: U12.8 (SSTX-); also elsewhere on the board
/OUT_HUB/SSTX3_P: U12.9 (SSTX+); also elsewhere on the board
/OUT_HUB/SSTX4_N: U13.8 (SSTX-); also elsewhere on the board
/OUT_HUB/SSTX4_P: U13.9 (SSTX+); also elsewhere on the board
GND: C82.2, C83.2, C84.2, C85.2, C86.2, C87.2, C88.2, C89.2, U10.4 (GND), U10.7 (GND_DRAN), U10.10 (SH), U11.4 (GND), U11.7 (GND_DRAN), U11.10 (SH), U12.4 (GND), U12.7 (GND_DRAN), U12.10 (SH), U13.4 (GND), U13.7 (GND_DRAN), U13.10 (SH); also elsewhere on the board

Parts:
C109: 100nF; C0603; Manufacturer Part CL10A105KB8NNNC; LCSC Part Name 1uF ±10% 50V
D8: SOD-323F_L1.7-W1.3-LS2.5-R-RD; Manufacturer Part 1N4148WSL; LCSC Part Name 1N4148WSL
FPC1, FPC2: FPC-SMD_40P-P0.50_XUNPU_FPC-05FB-40PH20; Manufacturer Part FPC-05FB-40PH20; LCSC Part Name 翻盖式 卧贴 P数:40P 间距:0.5mm
R85, R86: 2.2kΩ; R0603; Manufacturer Part 0603WAF1002T5E; LCSC Part Name 厚膜电阻 10kΩ ±1% 100mW
R89: 100kΩ; R0603; Manufacturer Part 0603WAF1002T5E; LCSC Part Name 厚膜电阻 10kΩ ±1% 100mW
U14: WFQFN-42_L9.0-W3.5-P0.50-BL-EP; Manufacturer Part TS3DV642A0RUAR; LCSC Part Name 具有1.8V兼容控制和断电模式的12通道1:2多路复用器/多路解复用器
USB7: HDMI-SMD_HDMI-001S; Manufacturer Part HDMI-001S; LCSC Part Name HDMI-001S

Connections:
+3V3: C109.1, U14.1 (VCC); also elsewhere on the board
+5V: D8.2, FPC1.19, FPC1.20, FPC1.21, FPC1.22, FPC2.19, FPC2.20, FPC2.21, FPC2.22, USB7.18 (+5V_Power); also elsewhere on the board
/HDMI_OUT/HDMI0_CLK_N: U14.5 (D0+), USB7.12 (TMDS_Clock-)
/HDMI_OUT/HDMI0_CLK_P: U14.6 (D0-), USB7.10 (TMDS_Clock+)
/HDMI_OUT/HDMI0_D0_N: U14.7 (D1+), USB7.9 (TMDS_Data_0-)
/HDMI_OUT/HDMI0_D0_P: U14.8 (D1-), USB7.7 (TMDS_Data_0+)
/HDMI_OUT/HDMI0_D1_N: U14.10 (D2+), USB7.6 (TMDS_Data_1-)
/HDMI_OUT/HDMI0_D1_P: U14.11 (D2-), USB7.4 (TMDS_Data_1+)
/HDMI_OUT/HDMI0_D2_N: U14.12 (D3+), USB7.3 (TMDS_Data_2-)
/HDMI_OUT/HDMI0_D2_P: U14.13 (D3-), USB7.1 (TMDS_Data_2+)
/HDMI_OUT/HDMI0_HDP: R89.1, U14.14 (HPD), USB7.19 (Hot_Plug_Detect)
/HDMI_OUT/HDMI0_SCL: R86.2, U14.3 (SCL), USB7.15 (SCL)
/HDMI_OUT/HDMI0_SDA: R85.2, U14.4 (SDA), USB7.16 (SDA)
/HDMI_OUT/HDMI1_CLK_N: FPC2.36, U14.29 (D0+B)
/HDMI_OUT/HDMI1_CLK_P: FPC2.35, U14.28 (D0-B)
/HDMI_OUT/HDMI1_D0_N: FPC2.33, U14.27 (D1+B)
/HDMI_OUT/HDMI1_D0_P: FPC2.32, U14.26 (D1-B)
/HDMI_OUT/HDMI1_D1_N: FPC2.30, U14.25 (D2+B)
/HDMI_OUT/HDMI1_D1_P: FPC2.29, U14.24 (D2-B)
/HDMI_OUT/HDMI1_D2_N: FPC2.27, U14.23 (D3+B)
/HDMI_OUT/HDMI1_D2_P: FPC2.26, U14.22 (D3-B)
/HDMI_OUT/HDMI1_HPD: FPC2.40, U14.21 (HPD_B)
/HDMI_OUT/HDMI1_SCL: FPC2.38, U14.40 (SCL_B)
/HDMI_OUT/HDMI1_SDA: FPC2.39, U14.39 (SDA_B)
/HDMI_OUT/HDMI2_CLK_N: FPC2.5, U14.38 (D0+A)
/HDMI_OUT/HDMI2_CLK_P: FPC2.6, U14.37 (D0-A)
/HDMI_OUT/HDMI2_D0_N: FPC2.8, U14.36 (D1+A)
/HDMI_OUT/HDMI2_D0_P: FPC2.9, U14.35 (D1-A)
/HDMI_OUT/HDMI2_D1_N: FPC2.11, U14.34 (D2+A)
/HDMI_OUT/HDMI2_D1_P: FPC2.12, U14.33 (D2-A)
/HDMI_OUT/HDMI2_D2_N: FPC2.14, U14.32 (D3+A)
/HDMI_OUT/HDMI2_D2_P: FPC2.15, U14.31 (D3-A)
/HDMI_OUT/HDMI2_HPD: FPC2.1, U14.19 (HPD_A)
/HDMI_OUT/HDMI2_SCL: FPC2.3, U14.42 (SCL_A)
/HDMI_OUT/HDMI2_SDA: FPC2.2, U14.41 (SDA_A)
/HDMI_OUT/HDMI_CK_N: FPC1.36; also elsewhere on the board
/HDMI_OUT/HDMI_CK_P: FPC1.35; also elsewhere on the board
/HDMI_OUT/HDMI_D0_N: FPC1.33; also elsewhere on the board
/HDMI_OUT/HDMI_D0_P: FPC1.32; also elsewhere on the board
/HDMI_OUT/HDMI_D1_N: FPC1.30; also elsewhere on the board
/HDMI_OUT/HDMI_D1_P: FPC1.29; also elsewhere on the board
/HDMI_OUT/HDMI_D2_N: FPC1.27; also elsewhere on the board
/HDMI_OUT/HDMI_D2_P: FPC1.26; also elsewhere on the board
/HDMI_OUT/HDMI_HPD: FPC1.40; also elsewhere on the board
/HDMI_OUT/HDMI_SCL: FPC1.38; also elsewhere on the board
/HDMI_OUT/HDMI_SDA: FPC1.39; also elsewhere on the board
/HDMI_OUT/TMDS_CLK_N: FPC1.5; also elsewhere on the board
/HDMI_OUT/TMDS_CLK_P: FPC1.6; also elsewhere on the board
/HDMI_OUT/TMDS_D0_N: FPC1.8; also elsewhere on the board
/HDMI_OUT/TMDS_D0_P: FPC1.9; also elsewhere on the board
/HDMI_OUT/TMDS_D1_N: FPC1.11; also elsewhere on the board
/HDMI_OUT/TMDS_D1_P: FPC1.12; also elsewhere on the board
/HDMI_OUT/TMDS_D2_N: FPC1.14; also elsewhere on the board
/HDMI_OUT/TMDS_D2_P: FPC1.15; also elsewhere on the board
/HDMI_OUT/TMDS_HPD: FPC1.1; also elsewhere on the board
/HDMI_OUT/TMDS_SCL: FPC1.3; also elsewhere on the board
/HDMI_OUT/TMDS_SDA: FPC1.2; also elsewhere on the board
/MCU/HDMI_EN: U14.2 (EN); also elsewhere on the board
/MCU/HDMI_SEL1: U14.16 (SEL1); also elsewhere on the board
/MCU/HDMI_SEL2: U14.17 (SEL2); also elsewhere on the board
GND: C109.2, FPC1.4, FPC1.7, FPC1.10, FPC1.13, FPC1.16, FPC1.17, FPC1.18, FPC1.23, FPC1.24, FPC1.25, FPC1.28, FPC1.31, FPC1.34, FPC1.37, FPC1.41, FPC1.42, FPC2.4, FPC2.7, FPC2.10, FPC2.13, FPC2.16, FPC2.17, FPC2.18, FPC2.23, FPC2.24, FPC2.25, FPC2.28, FPC2.31, FPC2.34, FPC2.37, FPC2.41, FPC2.42, R89.2, USB7.2 (TMDS_Data_2_Shield), USB7.5 (TMDS_Data_1_Shield), USB7.8 (TMDS_Data_0_Shield), USB7.11 (TMDS_Clock_Shield), USB7.14 (Reserved_(N.C.)), USB7.17 (DDC/CEC_Ground), USB7.20 (GND), USB7.21 (GND), USB7.22 (GND), USB7.23 (GND); also elsewhere on the board
unnamed: D8.1, R85.1, R86.1

Parts:
C90, C91, C92, C93, C94, C103: 1uF; C0603; Manufacturer Part CL10A105KB8NNNC; LCSC Part Name 1uF ±10% 50V
C95, C101: 100nF; C0603; Manufacturer Part CL10A105KB8NNNC; LCSC Part Name 1uF ±10% 50V
C96, C97, C98, C99, C100: 10uF; C0603; Manufacturer Part CL10A105KB8NNNC; LCSC Part Name 1uF ±10% 50V
D1, D2, D3, D4, D5, D6: SMB_L4.6-W3.6-LS5.3-RD; Manufacturer Part SMBJ5.0A; LCSC Part Name 单向TVS 5V截止 峰值浪涌电流：65.3A@10/1000us
F1, F2, F3, F4, F5, F6: F1206; Manufacturer Part SMD1206-050-33; LCSC Part Name SMD1206-050-33
L1, L2: 2.2uH; IND-SMD_L7.0-W6.6; Manufacturer Part FXL0630-2R2-M; LCSC Part Name 2.2uH ±20% 10A
Q1, Q5, Q8, Q11, Q14, Q17: SOT-23-3_L2.9-W1.3-P0.95-LS2.4-BR-1; Manufacturer Part DMG2305UX; LCSC Part Name 耐压:20V 电流:4.1A
Q2, Q3, Q4, Q6, Q7, Q9, Q10, Q12, Q13, Q15, Q16, Q18: SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR; Manufacturer Part MMBT4403LT1G; LCSC Part Name PNP 电流:600mA 电压:40V
R64, R67, R69, R71, R73, R83: 47K; R0603; Manufacturer Part 0603WAF1002T5E; LCSC Part Name 厚膜电阻 10kΩ ±1% 100mW
R65, R66, R68, R70, R72, R82: 10K; R0603; Manufacturer Part 0603WAF1002T5E; LCSC Part Name 厚膜电阻 10kΩ ±1% 100mW
R74, R75: 150K; R0603; Manufacturer Part 0603WAF1002T5E; LCSC Part Name 厚膜电阻 10kΩ ±1% 100mW
R76: 680K; R0603; Manufacturer Part 0603WAF1002T5E; LCSC Part Name 厚膜电阻 10kΩ ±1% 100mW
R77: 100K; R0603; Manufacturer Part 0603WAF1002T5E; LCSC Part Name 厚膜电阻 10kΩ ±1% 100mW
U15: TSOT-23-8_L2.9-W1.6-P0.65-LS2.8-BL; Manufacturer Part MP2122AGJ-Z; LCSC Part Name 6V, 2A, 低静态电流, 双路同步降压稳压器
U16: SOT-223-4_L6.5-W3.5-P2.30-LS7.0-BR; Manufacturer Part AMS1117-3.3; LCSC Part Name 输出:3.3V 电流:1A 耐压:12V

Connections:
+1V0: C98.2, L2.2, R77.2; also elsewhere on the board
+3.3V: C100.2, C101.2, U16.2 (VOUT(TAB)), U16.4 (TAB); also elsewhere on the board
+3V3: C97.2, L1.2, R76.2; also elsewhere on the board
+5V: C95.2, C96.2, C99.2, Q1.2 (S), Q3.2 (E), Q5.2 (S), Q6.2 (E), Q8.2 (S), Q9.2 (E), Q11.2 (S), Q12.2 (E), Q14.2 (S), Q15.2 (E), Q17.2 (S), Q18.2 (E), U15.2 (EN2), U15.4 (EN1), U15.7 (IN), U16.3 (VIN); also elsewhere on the board
/Power/HDMI_VBUS: F6.1; also elsewhere on the board
/Power/TMDS_5V: F3.1; also elsewhere on the board
/Power/TypeC_1_5V: F1.1; also elsewhere on the board
/Power/TypeC_2_5V: F5.1; also elsewhere on the board
/Power/TypeC_3_5V: F2.1; also elsewhere on the board
/Power/TypeC_4_5V: F4.1; also elsewhere on the board
GND: C90.1, C91.1, C92.1, C93.1, C94.1, C95.1, C96.1, C97.1, C98.1, C99.1, C100.1, C101.1, C103.1, D1.2, D2.2, D3.2, D4.2, D5.2, D6.2, R64.2, R65.2, R66.2, R67.2, R68.2, R69.2, R70.2, R71.2, R72.2, R73.2, R74.2, R75.2, R82.2, R83.2, U15.5 (GND), U16.1 (ADJ(GND)); also elsewhere on the board
unnamed: C90.2, D1.1, F1.2, Q1.3 (D), Q2.2 (E)
unnamed: Q1.1 (G), Q3.3 (C), R64.1
unnamed: Q2.1 (B), Q2.3 (C), Q3.1 (B), R65.1
unnamed: Q4.1 (B), Q4.3 (C), Q6.1 (B), R66.1
unnamed: C91.2, D2.1, F5.2, Q4.2 (E), Q5.3 (D)
unnamed: Q5.1 (G), Q6.3 (C), R67.1
unnamed: Q7.1 (B), Q7.3 (C), Q9.1 (B), R68.1
unnamed: C92.2, D3.1, F2.2, Q7.2 (E), Q8.3 (D)
unnamed: Q8.1 (G), Q9.3 (C), R69.1
unnamed: Q10.1 (B), Q10.3 (C), Q12.1 (B), R70.1
unnamed: C93.2, D4.1, F4.2, Q10.2 (E), Q11.3 (D)
unnamed: Q11.1 (G), Q12.3 (C), R71.1
unnamed: Q13.1 (B), Q13.3 (C), Q15.1 (B), R72.1
unnamed: C94.2, D5.1, F6.2, Q13.2 (E), Q14.3 (D)
unnamed: Q14.1 (G), Q15.3 (C), R73.1
unnamed: Q16.1 (B), Q16.3 (C), Q18.1 (B), R82.1
unnamed: C103.2, D6.1, F3.2, Q16.2 (E), Q17.3 (D)
unnamed: Q17.1 (G), Q18.3 (C), R83.1
unnamed: R75.1, R76.1, U15.8 (FB1)
unnamed: R74.1, R77.1, U15.1 (FB2)
unnamed: L1.1, U15.6 (SW1)
unnamed: L2.1, U15.3 (SW2)

Notes on the sheet:
防浪涌电路
计算公式:0.6*(1+R1/R2) 上路输出为3.32v 下路为1.0v
LDO 3v3
负责MCU供电
DCDC 3v3 1v0

Parts:
C102, C104, C105, C106, C107, C108, C110, C111, C112, C113, C114, C115: 100nF; C0603; Manufacturer Part CL10A105KB8NNNC; LCSC Part Name 1uF ±10% 50V
CN1: CONN-TH_3P-P1.25_GH1.25; Manufacturer Part WAFER-GH1.25-3PWB; LCSC Part Name 1x3P 间距:1.25mm 卧贴 系列:GH
H1, H2: HDR-TH_4P-P2.54-V-M; Manufacturer Part PZ254V-11-04P; LCSC Part Name 1x4P 间距:2.54mm 方针 直插
R78, R79, R80, R92, R93, R94, R95, R96, R97: 10kΩ; R0603; Manufacturer Part 0603WAF1002T5E; LCSC Part Name 厚膜电阻 10kΩ ±1% 100mW
SW1, SW2, SW3, SW4, SW5, SW6, SW7: SW-SMD_4P-L4.2-W3.2-P2.15-LS4.6-1; Manufacturer Part TS3425BA; LCSC Part Name 4.2*3.2*2.5mm 立贴 轻触开关
U17: LQFP-48_L7.0-W7.0-P0.50-LS9.0-BL; Manufacturer Part STM32F103CBT6; LCSC Part Name 主流增强型ARM Cortex-M3 MCU，具有128 KB Flash、7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
U18: CONN-SMD_4P-P1.25_XUNPU_WAFER-GH1.25-4PWB; Manufacturer Part WAFER-GH1.25-4PWB; LCSC Part Name 1x4P 间距:1.25mm 卧贴 系列:GH
X2: 8MHz; OSC-SMD_3P-L3.2-W1.3-P1.20-L; Manufacturer Part CSTNE8M00G550000R0; LCSC Part Name 8MHz ±0.5% 内置负载电容:33pF

Connections:
+3.3V: C102.2, C104.2, C105.2, C106.2, C107.2, H1.1, H2.3, R80.2, R92.2, R93.2, R94.2, R95.2, R96.2, R97.2, U17.1 (VBAT), U17.9 (VDD_A), U17.24 (VDD_1), U17.36 (VDD_2), U17.48 (VDD_3), U18.4; also elsewhere on the board
/MCU/Connect_RX: CN1.1, U17.31 (PA10USART1_RXTIM1_CH3)
/MCU/Connect_TX: CN1.2, U17.30 (PA9USART1_TXTIM1_CH2)
/MCU/GPIO_1: U17.21 (PB10I2C2_SCLUSART3_TX); also elsewhere on the board
/MCU/GPIO_2: U17.22 (PB11I2C2_SDAUSART3_RX-); also elsewhere on the board
/MCU/HDMI_EN: C115.1, R97.1, SW7.2, U17.19 (PB1ADC12_IN9TIM3_CH4), U17.41 (PB5I2C1_SMBA); also elsewhere on the board
/MCU/HDMI_KEY: C113.1, R95.1, SW5.2, U17.25 (PB12SPI2_NSSI2C2_SMBAUSART3_CKTIM1_BKIN)
/MCU/HDMI_SEL1: U17.40 (PB4NJTRST); also elsewhere on the board
/MCU/HDMI_SEL2: U17.39 (PB3JTDO); also elsewhere on the board
/MCU/HUB_KEY1: C110.1, R92.1, SW2.2, U17.29 (PA8USART1_CKTIM1_CH1MCO)
/MCU/HUB_KEY2: C112.1, R94.1, SW4.2, U17.28 (PB15SPI2_MOSITIM1_CH3N)
/MCU/HUB_KEY3: C114.1, R96.1, SW6.2, U17.27 (PB14SPI2_MISOUSART3_RTSTIM1_CH2N)
/MCU/HUB_KEY4: C111.1, R93.1, SW3.2, U17.26 (PB13SPI2_SCKUSART3_CTSTIM1_CH1N)
/MCU/HUB_SEL0: U17.33 (PA12USART1_RTSCAN_TXTIM1_ETRUSBDP); also elsewhere on the board
/MCU/HUB_SEL1: U17.32 (PA11USART1_CTSCAN_RXTIM1_CH4USBDM); also elsewhere on the board
/MCU/I2C_SCL: H2.2, U17.42 (PB6I2C1_SCLTIM4_CH1)
/MCU/I2C_SDA: H2.1, U17.43 (PB7I2C1_SDATIM4_CH2)
/MCU/OSC_IN: U17.5 (PD0-OSC_IN), X2.1 (OSC1)
/MCU/OSC_OUT: U17.6 (PD1-OSC_OUT), X2.3 (OSC2)
/MCU/RST: C108.1, R80.1, SW1.2, U17.7 (NRST)
/MCU/SWCLK: U17.37 (PA14JTCKSWCLK), U18.3
/MCU/SWDIO: U17.34 (PA13JTMSSWDIO), U18.2
/MCU/USART2_RX: H1.4, U17.13 (PA3USART2_RXADC12_IN3TIM2_CH4)
/MCU/USART2_TX: H1.3, U17.12 (PA2USART2_TXADC12_IN2TIM2_CH3)
GND: C102.1, C104.1, C105.1, C106.1, C107.1, C108.2, C110.2, C111.2, C112.2, C113.2, C114.2, C115.2, CN1.3, CN1.4, CN1.5, H1.2, H2.4, R78.2, R79.1, SW1.4, SW2.4, SW3.4, SW4.4, SW5.4, SW6.4, SW7.4, U17.8 (VSS_A), U17.23 (VSS_1), U17.35 (VSS_2), U17.47 (VSS_3), U18.1, U18.5, U18.6, X2.2 (GND); also elsewhere on the board
unnamed: R78.1, U17.44 (BOOT0)
unnamed: R79.2, U17.20 (PB2BOOT1)

Board: 2 copper layers, 291 parts (5 on the bottom side), 330 nets, no tracks yet.

## Code that names these connections

File Software/ChinoHuB/ChinoHuB.ioc (part):

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Mcu.Name=STM32F103C(8-B)Tx
Mcu.Package=LQFP48
Mcu.UserName=STM32F103CBTx
PA10.GPIOParameters=GPIO_Label
PA10.GPIO_Label=Connect_RX
PA10.Mode=Asynchronous
PA10.Signal=USART1_RX
PA11.GPIOParameters=GPIO_Label
PA11.GPIO_Label=HUB_SEL1
PA11.Signal=GPIO_Output
PA12.GPIOParameters=GPIO_Label
PA12.GPIO_Label=HUB_SEL0
PA12.Signal=GPIO_Output
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA2.Mode=Asynchronous
PA2.Signal=USART2_TX
PA3.Mode=Asynchronous
PA3.Signal=USART2_RX
PA8.GPIOParameters=GPIO_Label
PA8.GPIO_Label=HUB_KEY1
PA8.Signal=GPIO_Input
PA9.GPIOParameters=GPIO_Label
PA9.GPIO_Label=Connect_TX
PA9.Mode=Asynchronous
PA9.Signal=USART1_TX
PB1.GPIOParameters=GPIO_Label
PB1.GPIO_Label=HDMI_EN
PB1.Signal=GPIO_Input
PB10.GPIOParameters=GPIO_Label
PB10.GPIO_Label=GPIO1
PB10.Signal=GPIO_Output
PB11.GPIOParameters=GPIO_Label
PB11.GPIO_Label=GPIO2
PB11.Signal=GPIO_Output
PB12.GPIOParameters=GPIO_Label
PB12.GPIO_Label=HDMI_KEY
PB12.Signal=GPIO_Input
PB13.GPIOParameters=GPIO_Label
PB13.GPIO_Label=HUB_KEY4
PB13.Signal=GPIO_Input
PB14.GPIOParameters=GPIO_Label
PB14.GPIO_Label=HUB_KEY3
PB14.Signal=GPIO_Input
PB15.GPIOParameters=GPIO_Label
PB15.GPIO_Label=HUB_KEY2
PB15.Signal=GPIO_Input
PB3.GPIOParameters=GPIO_Label
PB3.GPIO_Label=HDMI_SEL2
PB3.Signal=GPIO_Output
PB4.GPIOParameters=GPIO_Label
PB4.GPIO_Label=HDMI_SEL1
PB4.Signal=GPIO_Output
PB5.GPIOParameters=GPIO_Label
PB5.GPIO_Label=HDMI_EN
PB5.Signal=GPIO_Output
PB6.Mode=I2C
PB6.Signal=I2C1_SCL
PB7.Mode=I2C
PB7.Signal=I2C1_SDA
PD0-OSC_IN.Mode=HSE-External-Oscillator
PD0-OSC_IN.Signal=RCC_OSC_IN
PD1-OSC_OUT.Mode=HSE-External-Oscillator
PD1-OSC_OUT.Signal=RCC_OSC_OUT
RCC.SYSCLKFreq_VALUE=72000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log

2025-09-19 首次提交
2025-09-24 完成USB3.0输入原理图
2025-09-26 完成对系统框图的绘制
2025-09-26 完成TypeC转HDMI部分
2025-09-26 临时测试
2025-09-29 完成HUB部分原理图绘制
2025-09-29 完成HUB部分基础内容
2025-09-29 增加基础的STM32代码
2025-10-03 完成除MCU外的设计
2025-10-03 修改了电源供电部分的内容
2025-10-04 complete sch
2025-10-04 修改了一些小错误,并补充部分外设
2025-10-05 开始PCB布局
